# Keil uVision project Pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4
  c misc: --cpp
  c include: ..\Libraries\inc;..\Libraries\src;..\CIMIS;..\Startup;..\User;..\User\Code_C\inc;..\User\Code_C\src;..\User\Code_C++\inc;..\User\Code_C++\src;..\User\DSP\Include;..\User\DSP\FastMathFunctions;..\User\SDCard
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../User/: main.c
    ../User/Code_C/src/: Scheduler.c Communication.c FlyControl.c Attitude.c Position.c SysState.c Math_User.c CarControl.c SD_APP.c
  group Code_C++
    ../User/Code_C++/src/: Target.cpp I2C_Soft.cpp Filter.cpp PID.cpp GPS_Parse.cpp
  group Driver
    ../User/Code_C/src/: MPU6050.c HMC5883.c Motor.c MS5611.c Time.c Led.c PWM_Capture.c Battery.c GPS_UART.c Buzzer.c USART.c SDCard.c Queue.c SBUS.c Ultra.c HallSpeed.c
  group Startup
    ../Startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../CIMIS/: system_stm32f4xx.c
  group Library
    ../User/: stm32f4xx_it.c
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_flash.c
  group DSP
    ../User/DSP/CommonTables/: arm_common_tables.c
    ../User/DSP/FastMathFunctions/: arm_sin_f32.c arm_cos_f32.c
  group SD_FAT
    ../User/SDCard/: diskio.c ff.c
